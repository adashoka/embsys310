<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\my_pwm_experiment.ewp</path>
  </project>
  <batchBuild />
</workspace>
